COMPATIBLE_MACHINE = "omap4|omap5"

EXTRA_OECONF += "--enable-omap-experimental-api"
