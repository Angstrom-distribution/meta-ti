require ti-hdvpss.inc

SRC_URI[md5sum] = "6db908bef3b933dc8cea666564d5d4d8"
SRC_URI[sha256sum] = "2caa9c859cfe348197e860f07d174a8ab7048d38d6d3a12ec576802122c9e91e"


