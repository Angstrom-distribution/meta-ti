require ti-cgt6x.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=62f46f1125a152a2e213b414db7ac600"

PE = "1"
PV = "7_2_7"
PVwithdots = "7.2.7"

SRC_URI[cgt6xbin.md5sum] = "71a0768a541fdebd9c35d44301019d1d"
SRC_URI[cgt6xbin.sha256sum] = "211477f0142d603975544abe3c45cc3b77a3b38038158676c60812806378738b"

