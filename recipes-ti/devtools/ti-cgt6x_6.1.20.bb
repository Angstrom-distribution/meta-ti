require ti-cgt6x.inc

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=62f46f1125a152a2e213b414db7ac600"

PE = "1"
PV = "6_1_20"
PVwithdots = "6.1.20"

SRC_URI[cgt6xbin.md5sum] = "39485ea8211960de0a958ab27106ab9b"
SRC_URI[cgt6xbin.sha256sum] = "a020142011c8160e24f6386f7696ecfbfe02dab2a6c83af74ce6b67eb1da9900"

