require ti-xdctools.inc

PV = "3_22_01_21"

LIC_FILES_CHKSUM = "file://docs/license/xdc/shelf/package.html;md5=28f68a7ade87b486509031cbdd58dc68"

SRC_URI[xdcbin.md5sum] = "1cb1190ce1c620fb5f5f0a054893ac1d"
SRC_URI[xdcbin.sha256sum] = "c2d2b2293c56e4f6914999124dcb9328aea36d343eef24fc634db69f20c3e164"

