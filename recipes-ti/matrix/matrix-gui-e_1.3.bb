require matrix-gui-e.inc

SRCREV = "275"
SRC_URI += "file://0001-matrix_gui.pro-add-dbus-to-QT-features-to-fix-linkin.patch"


