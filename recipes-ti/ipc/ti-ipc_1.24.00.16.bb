require ti-ipc.inc

PV = "1_24_00_16"

LIC_FILES_CHKSUM = "file://ipc_${PV}_manifest.html;md5=573f5a5c0448d28bf8db35f438244d7f"

SRC_URI[ipcbin.md5sum] = "d2f7cc82310d555ca039dcd353bd94c5"
SRC_URI[ipcbin.sha256sum] = "96df7835e920c7dabcd63d30ec8bc2aea7cd0c6197c9fb9ca0f8a9b681aa5396"
