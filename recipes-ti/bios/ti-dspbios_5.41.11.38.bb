require ti-dspbios.inc

PV = "5_41_11_38"

SRC_URI[biosbin.md5sum] = "7fab13740c25f5b34b331bcdc759536e"
SRC_URI[biosbin.sha256sum] = "96b8e090f79420a4c11d9c0c10d182d1d3b4afb48f11ec375c97b4c91970d0a0"

