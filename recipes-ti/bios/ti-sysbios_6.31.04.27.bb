require ti-sysbios.inc

PV = "6_31_04_27"
LIC_FILES_CHKSUM = "file://sysbios_6_31_04_27_manifest.html;md5=36efea2939274c46b73f5e170abaffcb"

SRC_URI[sysbiosbin.md5sum] = "c82e1d3afc9e2d3e88b0e4137f152ed6"
SRC_URI[sysbiosbin.sha256sum] = "92337cf3197d2b7ffe2316f311cd163be7b470acbb032273894d7d39182f4227"

